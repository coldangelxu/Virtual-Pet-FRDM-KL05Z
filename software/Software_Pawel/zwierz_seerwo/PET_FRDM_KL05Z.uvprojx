# Keil uVision project PET_FRDM_KL05Z.uvprojx, settings and files
target FRDM-KL05Z (6160000::V6.16::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PET_FRDM_KL05Z
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c i2c.c klaw.c lcd1602.c leds.c TPM.c tsi.c servos.c
software components: CMSIS:CORE 6.4.0, Device:Startup 1.0.0
